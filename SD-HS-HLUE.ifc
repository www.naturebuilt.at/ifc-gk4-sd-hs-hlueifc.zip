Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement [Architecture]
File name: 2018_01
Time: 2023-07-17T09:51:41+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternativ-UI 23.0.11.19

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcBuildingElementProxy: Modelltext:600mm Arial (3)
In: Default
Pset_BuildingElementProxyCommon - Reference: 600mm Arial; sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 0.15 m
Name (Modelltext:600mm Arial:...) | Width (m) = Height (m)
2499399 | 0.0251141
2499403 | 0.0251141
2499405

# IfcRoof: Basisdach:fbimSg_Roof_lb_WOD_vis_at_NTR_natuREbuilt_SD-HS-HLÜ_GK4, Basisdach:fbimSg_Roof_lb_WOD_vis_at_NTR_natuREbuilt_SD-HS-HLÜ_GK4:2499430
In: Default
Material: fbim_12451505_AT_001_Tondachstein 0.04 m, fbim_12400520_AT_001_Vollholz_Lattung_Fichte 0.03 m, fbim_14100590_AT_001_Luftschicht 0.05 m, fbim_12400515_AT_025_Vollholz_Bretter_Fichte 0.024 m, fbim_14100535_AT_091_Zellulose_Dämmplatte 0.1 m, fbim_12402010_AT_001_Holztraeger_massiv_ungehobelt 0.26 m, fbim_12401520_AT_001_OSB_Platte 0.015 m, fbim_14101045_AT_034_Mineralwolle_Daemmfilz 0.028 m, fbim_16101505_AT_001_Gipsfaserplatte_12.5mm 0.015 m
Pset_QuantityTakeOff - Reference: fbimSg_Roof_lb_WOD_vis_at_NTR_natuREbuilt_SD-HS-HLÜ_GK4
Pset_RoofCommon - Reference: fbimSg_Roof_lb_WOD_vis_at_NTR_natuREbuilt_SD-HS-HLÜ_GK4; IsExternal: yes; ProjectedArea: 42 m2; TotalArea: 48.4974 m2
